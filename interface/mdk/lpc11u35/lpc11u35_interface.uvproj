# Keil uVision project lpc11u35_interface.uvproj, settings and files
target lpc11u35_nrf51822_if (ARM-ADS)
  device: LPC11U35/401 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10001FFF) IRAM2(0x20004000-0x200047FF) IROM(0-0xFFFF) CLOCK(12000000) CPUTYPE("Cortex-M0")
  output: BB2000.01.A.3-001
  BeforeMake: python ..\..\..\tools\pre_build_script.py
  AfterMake: $KARM\BIN\ElfDwT.exe #L
  AfterMake: $KARM\ARMCC\BIN\FROMELF.EXE --BIN --OUTPUT="@L.bin" "#L"
  c flags: Optim=3 OneElfS=1
  c define: TARGET_LPC11U35, __RTX, DBG_NRF51822, BOARD_BB200X
  c include: ..\..\..\shared\USBStack\INC;..\..\Common\inc;..\..\Common\src;..\..\target\hal\DBG_NordicSemi\DBG_NRF51822;..\..\interface\hal\TARGET_NXP\TARGET_LPC11U35;..\..\..\shared\cmsis;..\..\..\shared\cmsis\TARGET_NXP\TARGET_LPC11UXX;..\..\..\shared\rtos
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x10000000 size 0x2000
  memory RVCT10: RAM 0x20000000 size 0x800
  scatter file: ..\..\..\shared\cmsis\TARGET_NXP\TARGET_LPC11UXX\TOOLCHAIN_ARM_STD\LPC11U35.sct
  group CMSIS
    ../../../shared/cmsis/TARGET_NXP/TARGET_LPC11UXX/: system_LPC11Uxx.c
    ../../../shared/cmsis/TARGET_NXP/TARGET_LPC11UXX/TOOLCHAIN_ARM_STD/: startup_LPC11Uxx.s
  group Common
    ../../Common/src/: DAP.c dap_vendor_command.c main.c RTX_Config.c semihost.c SVC_Table.s SW_DP.c swd_host.c usb_config.c usbd_user_cdc_acm.c usbd_user_hid.c usbd_user_msc.c version.c board.c ihex.c serial.c
    ../../Common/inc/: mbed_htm.h
  group HAL-Interface
    ../../interface/hal/TARGET_NXP/TARGET_LPC11U35/: DAP_config.h gpio.c read_uid.c usbd_LPC11Uxx.c usb_buf.h uart4dummy.c
  group USBStack
    ../../../shared/USBStack/SRC/: usbd_cdc_acm.c usbd_core.c usbd_core_cdc.c usbd_core_hid.c usbd_core_msc.c usbd_hid.c usbd_msc.c
  group RTX
    ../../../shared/rtos/: HAL_CM1.c rt_Event.c rt_List.c rt_Mailbox.c rt_MemBox.c rt_Mutex.c rt_Robin.c rt_Semaphore.c rt_System.c rt_Task.c rt_Time.c rt_Timer.c
  group HAL-Target-NRF51822
    ../../target/hal/DBG_NordicSemi/DBG_nRF51822/: target_flash.h target_reset.c
  group HAL-Target-STM32F103RC
    ../../target/hal/DBG_STM/DBG_STM32F103RC/: target_flash.h target_reset.c
  group HAL-Target-STM32F051
    ../../target/hal/DBG_STM/DBG_STM32F051/: target_flash.h target_reset.c
  group HAL-Target-STM32F405
    ../../target/hal/DBG_STM/DBG_STM32F405/: target_reset.c target_flash.h
  group HAL-Target-LPC812
    ../../target/hal/DBG_NXP/DBG_LPC812/: target_reset.c
  group HAL-Target-LPC1768
    ../../target/hal/DBG_NXP/DBG_LPC1768/: target_reset.c
  group HAL-Target-LPC1114
    ../../target/hal/DBG_NXP/DBG_LPC1114/: target_reset.c
target lpc11u35_nrf51822_if_DT01 (ARM-ADS)
  device: LPC11U35/401 NXP (founded by Philips)
  cpu: as above
  output: dt01_nrf51822.01.A2-001
  BeforeMake: python ..\..\..\tools\pre_build_script.py
  AfterMake: $KARM\BIN\ElfDwT.exe #L
  AfterMake: $KARM\ARMCC\BIN\FROMELF.EXE --BIN --OUTPUT="@L.bin" "#L"
  c flags: Optim=3 OneElfS=1
  c define: TARGET_LPC11U35, __RTX, DBG_NRF51822, BOARD_DT01
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x10000000 size 0x2000
  memory RVCT10: RAM 0x20000000 size 0x800
  scatter file: as above
target lpc11u35_stm32f103rc_if (ARM-ADS)
  device: LPC11U35/401 NXP (founded by Philips)
  cpu: as above
  output: BB2001.01.A.3-001
  BeforeMake: python ..\..\..\tools\pre_build_script.py
  AfterMake: $KARM\BIN\ElfDwT.exe #L
  AfterMake: $KARM\ARMCC\BIN\FROMELF.EXE --BIN --OUTPUT="@L.bin" "#L"
  c flags: Optim=3 OneElfS=1
  c define: TARGET_LPC11U35, __RTX, DBG_STM32F103RC, BOARD_BB200X
  c include: ..\..\..\shared\USBStack\INC;..\..\Common\inc;..\..\Common\src;..\..\target\hal\DBG_STM\DBG_STM32F103RC;..\..\interface\hal\TARGET_NXP\TARGET_LPC11U35;..\..\..\shared\cmsis;..\..\..\shared\cmsis\TARGET_NXP\TARGET_LPC11UXX;..\..\..\shared\rtos
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x10000000 size 0x2000
  memory RVCT10: RAM 0x20000000 size 0x800
  scatter file: as above
target lpc11u35_stm32f103rc_if_DT01 (ARM-ADS)
  device: LPC11U35/401 NXP (founded by Philips)
  cpu: as above
  output: dt01_stm32f103rc.01.A2-001
  BeforeMake: python ..\..\..\tools\pre_build_script.py
  AfterMake: $KARM\BIN\ElfDwT.exe #L
  AfterMake: $KARM\ARMCC\BIN\FROMELF.EXE --BIN --OUTPUT="@L.bin" "#L"
  c flags: Optim=3 OneElfS=1
  c define: TARGET_LPC11U35, __RTX, DBG_STM32F103RC, BOARD_DT01
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x10000000 size 0x2000
  memory RVCT10: RAM 0x20000000 size 0x800
  scatter file: as above
target lpc11u35_stm32f051_if_DT01 (ARM-ADS)
  device: LPC11U35/401 NXP (founded by Philips)
  cpu: as above
  output: dt01_stm32f051.01.A2-001
  BeforeMake: python ..\..\..\tools\pre_build_script.py
  AfterMake: $KARM\BIN\ElfDwT.exe #L
  AfterMake: $KARM\ARMCC\BIN\FROMELF.EXE --BIN --OUTPUT="@L.bin" "#L"
  c flags: Optim=3 OneElfS=1
  c define: TARGET_LPC11U35, __RTX, DBG_STM32F051, BOARD_DT01
  c include: ..\..\..\shared\USBStack\INC;..\..\Common\inc;..\..\Common\src;..\..\target\hal\DBG_STM\DBG_STM32F051;..\..\interface\hal\TARGET_NXP\TARGET_LPC11U35;..\..\..\shared\cmsis;..\..\..\shared\cmsis\TARGET_NXP\TARGET_LPC11UXX;..\..\..\shared\rtos
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x10000000 size 0x2000
  memory RVCT10: RAM 0x20000000 size 0x800
  scatter file: as above
target lpc11u35_stm32f405_if (ARM-ADS)
  device: LPC11U35/401 NXP (founded by Philips)
  cpu: as above
  output: BB3002.01.A.1-001
  BeforeMake: python ..\..\..\tools\pre_build_script.py
  AfterMake: $KARM\BIN\ElfDwT.exe #L
  AfterMake: $KARM\ARMCC\BIN\FROMELF.EXE --BIN --OUTPUT="@L.bin" "#L"
  c flags: Optim=3 OneElfS=1
  c define: TARGET_LPC11U35, __RTX, DBG_STM32F405, BOARD_BB200X
  c include: ..\..\..\shared\USBStack\INC;..\..\Common\inc;..\..\Common\src;..\..\target\hal\DBG_STM\DBG_STM32F405;..\..\interface\hal\TARGET_NXP\TARGET_LPC11U35;..\..\..\shared\cmsis;..\..\..\shared\cmsis\TARGET_NXP\TARGET_LPC11UXX;..\..\..\shared\rtos
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x10000000 size 0x2000
  memory RVCT10: RAM 0x20000000 size 0x800
  scatter file: as above
target lpc11u35_stm32f405_if_DT01 (ARM-ADS)
  device: LPC11U35/401 NXP (founded by Philips)
  cpu: as above
  output: DT3002.01.A.1-001
  BeforeMake: python ..\..\..\tools\pre_build_script.py
  AfterMake: $KARM\BIN\ElfDwT.exe #L
  AfterMake: $KARM\ARMCC\BIN\FROMELF.EXE --BIN --OUTPUT="@L.bin" "#L"
  c flags: Optim=3 OneElfS=1
  c define: TARGET_LPC11U35, __RTX, DBG_STM32F405, BOARD_DT01
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x10000000 size 0x2000
  memory RVCT10: RAM 0x20000000 size 0x800
  scatter file: as above
target lpc11u35_nrf51822_Test (ARM-ADS)
  device: LPC11U35/401 NXP (founded by Philips)
  cpu: as above
  output: bb2000.bin
  BeforeMake: python ..\..\..\tools\pre_build_script.py
  AfterMake: $KARM\BIN\ElfDwT.exe #L
  AfterMake: $KARM\ARMCC\BIN\FROMELF.EXE --BIN --OUTPUT="@L.bin" "#L"
  c flags: Optim=3 OneElfS=1
  c define: TARGET_LPC11U35, __RTX, DBG_NRF51822, BOARD_BB200X
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x10000000 size 0x2000
  memory RVCT10: RAM 0x20000000 size 0x800
  scatter file: as above
target lpc11u35_lpc812_if (ARM-ADS)
  device: LPC11U35/401 NXP (founded by Philips)
  cpu: as above
  output: lpc11u35_lpc812_if_mbed
  AfterMake: $KARM\BIN\ElfDwT.exe #L
  AfterMake: $KARM\ARMCC\BIN\FROMELF.EXE --BIN --OUTPUT=".\11u35_lpc812_if_mbed.bin" "#L"
  c flags: Optim=3 OneElfS=1
  c define: TARGET_LPC11U35, __RTX, DBG_LPC812, BOARD_LPC812_MAX
  c include: ..\..\..\shared\USBStack\INC;..\..\Common\inc;..\..\Common\src;..\..\target\hal\DBG_NXP\DBG_LPC812;..\..\interface\hal\TARGET_NXP\TARGET_LPC11U35;..\..\interface\cmsis;..\..\interface\cmsis\TARGET_NXP\TARGET_LPC11UXX;..\..\..\shared\rtos
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x10000000 size 0x2000
  memory RVCT10: RAM 0x20000000 size 0x800
  scatter file: as above
target lpc11u35_lpc812_mbed_bootloader (ARM-ADS)
  device: LPC11U35/401 NXP (founded by Philips)
  cpu: as above
  output: lpc11u35_lpc812_if_mbed_bootloader
  c flags: Optim=3
  c define: TARGET_LPC11U35, __RTX, DBG_LPC812, BOARD_LPC812_MAX
  c include: ..\..\..\shared\USBStack\INC;..\..\Common\inc;..\..\Common\src;..\..\interface\cmsis;..\..\interface\hal\TARGET_NXP\TARGET_LPC11U35;..\..\target\hal\DBG_NXP\DBG_LPC812;..\..\..\shared\rtos
  asm define: NO_CRP
  library: MicroLIB
  memory RVCT4: ROM 0x5000 size 0xb000
  memory RVCT9: RAM 0x100000c0 size 0x1f40
  memory RVCT10: RAM 0x20000000 size 0x800
  scatter file: ..\..\..\shared\cmsis\TARGET_NXP\TARGET_LPC11UXX\TOOLCHAIN_ARM_STD\LPC11U35_mbed_bootloader.sct
target lpc11u35_lpc1768_if (ARM-ADS)
  device: LPC11U35/401 NXP (founded by Philips)
  cpu: as above
  output: lpc11u35_lpc1768_if_mbed
  c flags: Optim=1 oTime=1
  c define: TARGET_LPC11U35, __RTX, DBG_LPC1768, BOARD_SEEED_ARCH_PRO
  c include: ..\..\..\shared\USBStack\INC;..\..\Common\inc;..\..\Common\src;..\..\target\hal\DBG_NXP\DBG_LPC1768;..\..\interface\hal\TARGET_NXP\TARGET_LPC11U35;..\..\interface\cmsis;..\..\interface\cmsis\TARGET_NXP\TARGET_LPC11UXX;..\..\..\shared\rtos
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x10000000 size 0x2000
  memory RVCT10: RAM 0x20000000 size 0x800
  scatter file: as above
target lpc11u35_lpc1768_mbed_bootloader (ARM-ADS)
  device: LPC11U35/401 NXP (founded by Philips)
  cpu: as above
  output: lpc11u35_lpc1768_if_mbed_bootloader
  c flags: Optim=3 oTime=1
  c define: TARGET_LPC11U35, __RTX, DBG_LPC1768, BOARD_SEEED_ARCH_PRO
  c include: as above
  asm define: NO_CRP
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x10000000 size 0x2000
  memory RVCT10: RAM 0x20000000 size 0x800
  scatter file: as above
target lpc11u35_ublox_if (ARM-ADS)
  device: LPC11U35/401 NXP (founded by Philips)
  cpu: as above
  output: lpc11u35_lpc1768_if_mbed
  AfterMake: $KARM\BIN\ElfDwT.exe #L
  AfterMake: $KARM\ARMCC\BIN\FROMELF.EXE --BIN --OUTPUT=".\11u35_ublox_if_mbed.bin" "#L"
  c flags: Optim=1 oTime=1
  c define: TARGET_LPC11U35, __RTX, DBG_LPC1768, BOARD_UBLOX_C027
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x10000000 size 0x2000
  memory RVCT10: RAM 0x20000000 size 0x800
  scatter file: as above
target lpc11u35_lpc1114_if (ARM-ADS)
  device: LPC11U35/401 NXP (founded by Philips)
  cpu: as above
  output: lpc11u35_lpc1114_if_mbed
  c flags: Optim=3 oTime=1
  c define: TARGET_LPC11U35, __RTX, DBG_LPC1114, BOARD_LPC1114
  c include: ..\..\..\shared\USBStack\INC;..\..\Common\inc;..\..\Common\src;..\..\target\hal\DBG_NXP\DBG_LPC1114;..\..\interface\hal\TARGET_NXP\TARGET_LPC11U35;..\..\interface\cmsis;..\..\interface\cmsis\TARGET_NXP\TARGET_LPC11UXX;..\..\..\shared\rtos
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x10000000 size 0x2000
  memory RVCT10: RAM 0x20000000 size 0x800
  scatter file: as above
target lpc11u35_lpc1114_mbed_bootloader (ARM-ADS)
  device: LPC11U35/401 NXP (founded by Philips)
  cpu: as above
  output: lpc11u35_lpc1114_if_mbed
  c flags: Optim=3 oTime=1
  c define: TARGET_LPC11U35, __RTX, DBG_LPC1114, BOARD_LPC1114
  c include: as above
  asm define: NO_CRP
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x10000000 size 0x2000
  memory RVCT10: RAM 0x20000000 size 0x800
  scatter file: as above
target lpc11u35_lpc810_if (ARM-ADS)
  device: LPC11U35/501 NXP (founded by Philips)
  cpu: as above
  output: lpc11u35_lpc810_if_mbed
  c flags: Optim=3 oTime=1
  c define: TARGET_LPC11U35, __RTX, DBG_LPC810, BOARD_LPC810
  c include: ..\..\target\hal\DBG_NXP\DBG_LPC810;..\..\..\shared\USBStack\INC;..\..\Common\inc;..\..\Common\src;..\..\interface\hal\TARGET_NXP\TARGET_LPC11U35;..\..\..\shared\rtos
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x10000000 size 0x2000
  memory RVCT10: RAM 0x20004000 size 0x800
  scatter file: as above
